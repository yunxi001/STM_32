# Keil uVision project UAV_holder.uvprojx, settings and files
target UAV_holder (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F105R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x800FFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: UAV_holder +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC,USE_HAL_DRIVER,STM32F105xC
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; .\BSP_USER; .\TASK; .\MPU9250
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group bsp_user
    ./BSP_USER/: bsp_can.c pid.c Remote_Control.c robomaster_vcan.c user_lib.c laser.c TIM_delay.c fric.c
  group TASK
    ./TASK/: Init.c test_task .c shoot_task.c holder_task.c
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dma.c freertos.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group MPU9250
    ./MPU9250/: mpu9250.c filter.c bsp_mpu9250.c myiic.c
software components: CMSIS:CORE 4.3.0
